# Keil uVision project sensor-node-fw.uvprojx, settings and files
target sensor-node-fw (6230000::V6.23::ARMCLANG)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: sensor-node-fw +hex
  AfterMake: fromelf --bin --output "$L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE,QV_PRJ
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../App/inc;../Qpc/platform/inc;../Qpc/port/qv/inc;../App/app;../App/bsp;../App/service;../App/driver;../App/component;../App/component/ble;../App/component/ble/backend;../App/component/ble/examples;../App/component/modem;../App/component/modem/backend;..\App\app_command;../App/app_command
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c i2c.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group App
    ../App/app/: app.c ble.c command_dispatch.c heartbeat.c modem.c node.c sensor.c store.c system.c
  group Service
    ../App/service/: svc_at.c svc_filter.c svc_frame.c svc_log.c svc_param.c
  group Driver
    ../App/driver/: drv_at24c04.c drv_sensor.c
  group BSP
    ../App/bsp/: bsp.c bsp_ble_uart.c bsp_i2c.c bsp_modem_uart.c bsp_uart.c
  group Component
    ../App/component/ble/backend/: ble_vg6328.c
    ../App/component/ble/: ble_component.c ble_protocol.c
    ../App/component/modem/backend/: modem_ml307c.c modem_mn316.c modem_nt26.c
    ../App/component/modem/: modem_at.c modem_component.c
  group QP/C/platform
    ../Qpc/platform/src/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c qv.c
  group QP/C/port
    ../Qpc/port/qv/src/: qv_port.c
software components: CMSIS:CORE 4.3.0
